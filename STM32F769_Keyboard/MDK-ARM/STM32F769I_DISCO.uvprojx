# Keil uVision project STM32F769I_DISCO.uvprojx, settings and files
target STM32F769I_DISCO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I_DISCO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx
  c include: ../Core/Inc;  ../TouchGFX/App;  ../TouchGFX/target/generated;  ../TouchGFX/target;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Drivers/CMSIS/Include;  ../Drivers/BSP/Components/Common; ../LIBJPEG/App; ../LIBJPEG/Target; ../Utilities/JPEG; ../Middlewares/Third_Party/LibJPEG/include;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: STM32F769I_DISCO.sct
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp Buttons.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp HardwareMJPEGDecoder.cpp tgfx_jpeg_utils.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Middlewares/LibJPEG
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/containers/: keyboard.cpp pinyin.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_microsoftyahei_32_4bpp_0.cpp font_microsoftyahei_32_4bpp_10.cpp font_microsoftyahei_32_4bpp_15.cpp font_microsoftyahei_32_4bpp_17.cpp font_microsoftyahei_32_4bpp_18.cpp font_microsoftyahei_bold_28_4bpp_0.cpp font_microsoftyahei_bold_30_4bpp_0.cpp font_microsoftyahei_bold_30_4bpp_10.cpp font_microsoftyahei_bold_30_4bpp_11.cpp font_microsoftyahei_bold_30_4bpp_15.cpp font_microsoftyahei_bold_30_4bpp_17.cpp font_microsoftyahei_bold_30_4bpp_18.cpp font_microsoftyahei_bold_30_4bpp_9.cpp font_microsoftyahei_bold_40_4bpp_0.cpp font_microsoftyahei_bold_40_4bpp_10.cpp font_microsoftyahei_bold_40_4bpp_11.cpp font_microsoftyahei_bold_40_4bpp_12.cpp font_microsoftyahei_bold_40_4bpp_13.cpp font_microsoftyahei_bold_40_4bpp_14.cpp font_microsoftyahei_bold_40_4bpp_15.cpp font_microsoftyahei_bold_40_4bpp_16.cpp font_microsoftyahei_bold_40_4bpp_17.cpp font_microsoftyahei_bold_40_4bpp_18.cpp font_microsoftyahei_bold_40_4bpp_19.cpp font_microsoftyahei_bold_40_4bpp_4.cpp font_microsoftyahei_bold_40_4bpp_9.cpp font_verdana_10_4bpp_0.cpp font_verdana_28_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_microsoftyahei_32_4bpp.cpp kerning_microsoftyahei_bold_28_4bpp.cpp kerning_microsoftyahei_bold_30_4bpp.cpp kerning_microsoftyahei_bold_40_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_28_4bpp.cpp kerning_verdana_40_4bpp.cpp table_microsoftyahei_32_4bpp.cpp table_microsoftyahei_bold_28_4bpp.cpp table_microsoftyahei_bold_30_4bpp.cpp table_microsoftyahei_bold_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_28_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/keyboard/: image_background.cpp image_bl_bt_pre.cpp image_bl_bt_rel.cpp image_cn_bt_pre.cpp image_cn_bt_rel.cpp image_cn_lift_bt_pre.cpp image_cn_lift_bt_rel.cpp image_cn_right_bt_pre.cpp image_cn_right_bt_rel.cpp image_cn_select_bt_pre.cpp image_cn_select_bt_rel.cpp image_dx_bt_rel.cpp image_eng_bt_pre.cpp image_eng_bt_rel.cpp image_eng_dx_bt_pre.cpp image_eng_dx_bt_rel.cpp image_ent_bt_pre.cpp image_ent_bt_rel.cpp image_fuhao_bt_pre.cpp image_fuhao_bt_rel.cpp image_fuhao_dele_bt_pre.cpp image_fuhao_dele_bt_rel.cpp image_fun_bt_pre.cpp image_fun_bt_rel.cpp image_mianbackgroun.cpp image_numb_bt_pre.cpp image_numb_bt_rel.cpp image_pinyin_bt_pre.cpp image_pinyin_bt_rel.cpp image_pinyin_select.cpp image_pinyin_select_pre.cpp image_pinyin_table.cpp
    ../touchgfx/generated/gui_generated/src/containers/: keyboardbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
software components: CMSIS:CORE 4.3.0
